# Keil uVision project usart_project.uvprojx, settings and files
target Target 1 (::::)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: usart_project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  group driver
    ../标准外设库实现LED流水灯/LED流水灯/user/: stm32f10x_it.c stm32f10x_conf.h stm32f10x_it.h
  group user
    ./: main.c User_USART.h User_USART.c
